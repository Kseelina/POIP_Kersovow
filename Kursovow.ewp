# IAR project Kursovow.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: R:\POIP\POIP\POIP2\CortexLib; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\CMSIS; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\include; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\Common; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\IAR; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\IAR\ARM_CM4F; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\MemMang; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\wrapper; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\wrapper\FreeRtos; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Thread; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Applications; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Applications\DataTransfer; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Applications\DataTransfer\Modbus; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Applications\Parameters; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware\PWM; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware\Flowmeter; R:\POIP\POIP\POIP2; R:\POIP\POIP\POIP2\CortexLib; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\Registers; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\Registers\STM32F411; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; R:\POIP\POIP\POIP2\CortexLib\Common; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\InterruptHandler; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware\ADC; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware\DMA; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; R:\POIP\POIP\POIP2\CortexLib\AbstractHardware\Registers\CortexM4; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Observer; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Hardware\TIM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: R:\POIP\POIP\POIP2\CortexLib; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\CMSIS; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\include; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\Common; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\IAR; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\IAR\ARM_CM4F; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\FreeRtos\portable\MemMang; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\wrapper; R:\POIP\POIP\POIP2\Kurs\POIP_Kersovow\Rtos\wrapper\FreeRtos
  OBJCOPY.OOCOutputFile: Kursovow.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: interrupthandler.hpp main.cpp StartUp.cpp
  group Applications/DataTransfer
    Applications/DataTransfer/: IDataSource.h
  group Applications/DataTransfer/Modbus
    Applications/DataTransfer/Modbus/: Modbus.h
  group Applications/Parameters
    Applications/Parameters/: CurrentControler.cpp CurrentControler.h IMeasureParameter.h Temperature.cpp Temperature.h WaterConsumtion.cpp WaterConsumtion.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h core_cm33.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group Common
    Common/: utils.hpp
  group Hardware/ADC
    Hardware/ADC/: ADC.cpp ADC.h Resistor.cpp Resistor.h
  group Hardware/DMA
    Hardware/DMA/: ConfigDMA.h DMA.h
  group Hardware/Flowmeter
    Hardware/Flowmeter/: Flowmeter.cpp Flowmeter.h
  group Hardware/PWM
    Hardware/PWM/: PWM.cpp PWM.h
  group Hardware/TIM
    Hardware/TIM/: TimerCCR.h
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/include
    Rtos/FreeRtos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Rtos/wrapper
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
  group Rtos/wrapper/FreeRtos
    Rtos/wrapper/FreeRtos/: rtosdefs.hpp rtoswrapper.hpp
  group Thread
    Thread/: CurrentPowerRegulationTask.cpp CurrentPowerRegulationTask.h DataTransferTask.h FlowTask.cpp FlowTask.h TemperatureTask.cpp TemperatureTask.h
